<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PIT.ewp</path>
    </project>
    <project>
        <path>C:\Users\DELL\Downloads\Uart_checkSrecord (1)\Uart_checkSrecord\Uart_checkSrecord.ewp</path>
    </project>
    <batchBuild />
</workspace>
