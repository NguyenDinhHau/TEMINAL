<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LED_PWM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\LedBlinking\project\LedBlinking.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\systick\project\systick1.ewp</path>
    </project>
    <batchBuild />
</workspace>
