# IAR project LED_PWM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: D:\ARM\TEMINAL\LED_PWM\CMSIS\Include; D:\ARM\TEMINAL\LED_PWM\MKL46Z; D:\ARM\TEMINAL\LED_PWM\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED_PWM.srec
  ILINK.IlinkOutputFile: LED_PWM.out
  ILINK.IlinkIcfFile: D:\ARM\TEMINAL\LED_PWM\project\MKL46Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: main_PWM.c
  group startup
    ../MKL46Z/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
