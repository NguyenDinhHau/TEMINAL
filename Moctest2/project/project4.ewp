# IAR project project4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: D:\ARM\Assignment_4\MKL46Z; D:\ARM\Assignment_4\source; D:\ARM\Assignment_4\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project4.srec
  ILINK.IlinkOutputFile: project4.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: APP.c Flash.c main.c QUEUE.c SRECORD.c UART.c
  group starup
    ../source/: APP.h Flash.h parse_src.h QUEUE.h SRECORD.h UART.h
    ../MKL46Z/: fsl_device_registers.h MKL46Z4_features.h startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
