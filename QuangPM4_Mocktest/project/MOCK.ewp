# IAR project MOCK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: C:\Users\ADMIN\Dropbox\C\FPT\embedded\QuangPM4_Mocktest\CMSIS\Include; C:\Users\ADMIN\Dropbox\C\FPT\embedded\QuangPM4_Mocktest\MKL46Z; C:\Users\ADMIN\Dropbox\C\FPT\embedded\QuangPM4_Mocktest\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MOCK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: app.c app.h Flash.c Flash.h gpio.c gpio.h main.c parse.c parse.h queue.c queue.h uart0.c uart0.h
  group startup
    ../MKL46Z/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
